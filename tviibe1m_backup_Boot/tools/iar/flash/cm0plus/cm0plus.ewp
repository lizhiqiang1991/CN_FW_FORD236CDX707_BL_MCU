# IAR project cm0plus.ewp, settings and files
configuration rev_b (ARM, debug)
  General.OGChipSelectEditMenu: CYT2B7_M0+ Infineon CYT2B7_M0+
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: tviibe1m; CYT2B75CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_b
  ICCARM.CCIncludePath2: $TVII_SDL_710$\common\hdr; $TVII_SDL_710$\common\hdr\cmsis\include; $TVII_SDL_710$\common\src\drivers; $TVII_SDL_710$\common\src\mw; $TVII_SDL_710$\tviibe1m\hdr\rev_b; $TVII_SDL_710$\tviibe1m\hdr\rev_b\ip; $TVII_SDL_710$\tviibe1m\hdr\rev_b\mcureg; $TVII_SDL_710$\tviibe1m\src; $TVII_SDL_710$\tviibe1m\src\interrupts\rev_b; $TVII_SDL_710$\tviibe1m\src\drivers; $TVII_SDL_710$\tviibe1m\src\system\rev_b
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: cm0plus.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: _CORE_$PROJ_FNAME$_=0; _LINK_$LINK_LOCATION$_=0
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe.icf
  ILINK.IlinkAdditionalLibs: $TVII_SDL_710$\tviibe1m\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rev_c (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibe1m; CYT2B78CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_c
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_c; ..\..\..\..\hdr\rev_c\ip; ..\..\..\..\hdr\rev_c\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_c; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_c
  ILINK.IlinkAdditionalLibs: ..\..\..\..\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a
configuration rev_d (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibe1m; CYT2B75CAE; CY_USE_PSVP=0; CPU_BOARD_REVC; CY_MCU_rev_d
  ICCARM.CCIncludePath2: $TVII_SDL_710$\common\hdr; $TVII_SDL_710$\common\hdr\cmsis\include; $TVII_SDL_710$\common\src\drivers; $TVII_SDL_710$\common\src\mw; $TVII_SDL_710$\tviibe1m\hdr\rev_b; $TVII_SDL_710$\tviibe1m\hdr\rev_b\ip; $TVII_SDL_710$\tviibe1m\hdr\rev_b\mcureg; $TVII_SDL_710$\tviibe1m\src; $TVII_SDL_710$\tviibe1m\src\interrupts\rev_b; $TVII_SDL_710$\tviibe1m\src\drivers; $TVII_SDL_710$\tviibe1m\src\system\rev_b; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\adc; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\clock; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\crypto; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\cy_hdr; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\fmc; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\gpio; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\hal_config; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\i2c; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\jump; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\pm; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\pwm; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\sp; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\spi; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\srom; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\sysreset; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\systick; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\timer; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\uart; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\hal\wdt; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\app; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\app\inc; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src\testbed; C:\TVII_Sample_Driver_Library_7.1.0\tviibe1m_backup\src
  OBJCOPY.OOCOutputFile: cdx707_boot.bin
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
  ILINK.IlinkAdditionalLibs: $TVII_SDL_710$\tviibe1m_backup\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a
configuration starter_kit (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: tviibe1m; CYT2B75CAE; CY_USE_PSVP=0; STARTER_KIT_REV3; CY_MCU_rev_d
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\hdr; ..\..\..\..\..\common\hdr\cmsis\include; ..\..\..\..\..\common\src\drivers; ..\..\..\..\..\common\src\mw; ..\..\..\..\hdr\rev_d; ..\..\..\..\hdr\rev_d\ip; ..\..\..\..\hdr\rev_d\mcureg; ..\..\..\..\src; ..\..\..\..\src\interrupts\rev_d; ..\..\..\..\src\drivers; ..\..\..\..\src\system\rev_d
  ILINK.IlinkIcfFile: ..\..\linker_directives_tviibe_rev_d.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\..\tviibe1m\src\drivers\crypto\libs\libcrypto_server_cm0plus_iar.a
  group hdr
    $TVII_SDL_710$/common/hdr/: cy_project.h
  group hdr/cmsis/include
    $TVII_SDL_710$/common/hdr/cmsis/include/: cmsis_compiler.h core_cm0plus.h
  group hdr/rev_b
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_b/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_b/ip
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_b/ip/: cyip_backup_v2.h cyip_canfd.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group hdr/rev_c
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_c/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_c/ip
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_c/ip/: cyip_backup_v2.h cyip_canfd.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group hdr/rev_d
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_d/: bb_bsp_tviibe1m.h bb_bsp_tviibe1m_reva.h bb_bsp_tviibe1m_revc.h bb_bsp_tviibe1m_starter_kit.h cy_device_headers.h cyt2b7_config.h
  group hdr/rev_d/ip
    $TVII_SDL_710$/tviibe1m_backup/hdr/rev_d/ip/: cyip_backup_v2.h cyip_canfd.h cyip_coredefines.h cyip_cpuss_v2.h cyip_crypto_v2.h cyip_dmac_v2.h cyip_dw_v2.h cyip_efuse_data_v2.h cyip_efuse_v2.h cyip_evtgen.h cyip_fault_v2.h cyip_flashc_v2.h cyip_gpio_v2.h cyip_headers.h cyip_hsiom_v2.h cyip_ipc_v2.h cyip_lin.h cyip_pass.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_prot_v2.h cyip_scb_v2.h cyip_sflash_v2.h cyip_smartio_v2.h cyip_srss_v2.h cyip_tcpwm_v2.h
  group Link_Script
    ../../: linker_directives_tviibe_rev_d.icf
  group src
    $TVII_SDL_710$/tviibe1m_backup/src/: main_cm0plus.c
  group src/app
    $TVII_SDL_710$/tviibe1m_backup/src/: app_main.c app_main.h
  group src/app/inc
    $TVII_SDL_710$/tviibe1m_backup/src/app/inc/: ClockApp.h CrcApp.h FlashRwApp.h FunApp.h I2c0SlaveApp.h InitApp.h PinIOApp.h Uart1App.h WatchDogApp.h
  group src/app/src
    $TVII_SDL_710$/tviibe1m_backup/src/app/src/: ClockApp.c CrcApp.c FlashRwApp.c FunApp.c I2c0SlaveApp.c InitApp.c PinIOApp.c Uart1App.c WatchDogApp.c
  group src/drivers/adc
    $TVII_SDL_710$/common/src/drivers/adc/: cy_adc.c cy_adc.h
  group src/drivers/canfd
    $TVII_SDL_710$/common/src/drivers/canfd/: cy_canfd.c cy_canfd.h
  group src/drivers/cpu
    $TVII_SDL_710$/tviibe1m_backup/src/drivers/cpu/: cy_cpu.c cy_cpu.h
  group src/drivers/crypto
    $TVII_SDL_710$/common/src/drivers/crypto/: cy_crypto.h cy_crypto_common.h cy_crypto_config.c cy_crypto_config.h cy_crypto_server.h
  group src/drivers/dma
    $TVII_SDL_710$/common/src/drivers/dma/: cy_mdma.c cy_mdma.h cy_pdma.c cy_pdma.h
  group src/drivers/evtgen
    $TVII_SDL_710$/common/src/drivers/evtgen/: cy_evtgen.c cy_evtgen.h
  group src/drivers/flash
    $TVII_SDL_710$/common/src/drivers/flash/: cy_flash.c
    $TVII_SDL_710$/tviibe1m_backup/src/drivers/flash/: cy_flash.h
  group src/drivers/gpio
    $TVII_SDL_710$/common/src/drivers/gpio/: cy_gpio.c cy_gpio.h
  group src/drivers/ipc
    $TVII_SDL_710$/common/src/drivers/ipc/: cy_ipc_config.h cy_ipc_drv.c cy_ipc_drv.h cy_ipc_pipe.c cy_ipc_pipe.h cy_ipc_sema.c cy_ipc_sema.h
  group src/drivers/lin
    $TVII_SDL_710$/common/src/drivers/lin/: cy_lin.c cy_lin.h
  group src/drivers/lvd
    $TVII_SDL_710$/common/src/drivers/lvd/: cy_lvd.c cy_lvd.h
  group src/drivers/mcwdt
    $TVII_SDL_710$/common/src/drivers/mcwdt/: cy_mcwdt.c cy_mcwdt.h
  group src/drivers/mpu
    $TVII_SDL_710$/common/src/drivers/mpu/: cy_mpu.c cy_mpu.h
  group src/drivers/prot
    $TVII_SDL_710$/common/src/drivers/prot/: cy_prot.c cy_prot.h
  group src/drivers/scb
    $TVII_SDL_710$/common/src/drivers/scb/: cy_scb_common.c cy_scb_common.h cy_scb_ezi2c.c cy_scb_ezi2c.h cy_scb_i2c.c cy_scb_i2c.h cy_scb_spi.c cy_scb_spi.h cy_scb_uart.c cy_scb_uart.h
  group src/drivers/smartio
    $TVII_SDL_710$/common/src/drivers/smartio/: cy_smartio.c cy_smartio.h
  group src/drivers/srom
    $TVII_SDL_710$/common/src/drivers/srom/: cy_srom.c cy_srom.h
  group src/drivers/sysclk
    $TVII_SDL_710$/tviibe1m_backup/src/drivers/sysclk/: cy_sysclk.c cy_sysclk.h
  group src/drivers/sysflt
    $TVII_SDL_710$/common/src/drivers/sysflt/: cy_sysflt.c cy_sysflt.h
  group src/drivers/sysint
    $TVII_SDL_710$/common/src/drivers/sysint/: cy_sysint.c cy_sysint.h
  group src/drivers/syslib
    $TVII_SDL_710$/common/src/drivers/syslib/: cy_syslib.c cy_syslib.h
    $TVII_SDL_710$/common/src/drivers/syslib/iar/: cy_syslib_iar.s
  group src/drivers/syspm
    $TVII_SDL_710$/common/src/drivers/syspm/: cy_syspm.c cy_syspm.h
  group src/drivers/sysreset
    $TVII_SDL_710$/common/src/drivers/sysreset/: cy_sysreset.c cy_sysreset.h
  group src/drivers/sysrtc
    $TVII_SDL_710$/common/src/drivers/sysrtc/: cy_sysrtc.c cy_sysrtc.h
  group src/drivers/systick
    $TVII_SDL_710$/common/src/drivers/systick/: cy_systick.c cy_systick.h
  group src/drivers/syswdt
    $TVII_SDL_710$/common/src/drivers/syswdt/: cy_syswdt.c cy_syswdt.h
  group src/drivers/tcpwm
    $TVII_SDL_710$/common/src/drivers/tcpwm/: cy_tcpwm.c cy_tcpwm.h cy_tcpwm_counter.c cy_tcpwm_counter.h cy_tcpwm_pwm.c cy_tcpwm_pwm.h cy_tcpwm_quaddec.c cy_tcpwm_quaddec.h cy_tcpwm_sr.c cy_tcpwm_sr.h
  group src/drivers/trigmux
    $TVII_SDL_710$/common/src/drivers/trigmux/: cy_trigmux.c cy_trigmux.h
  group src/hal
    $TVII_SDL_710$/tviibe1m_backup/src/hal/: hal_common.h hal_config.h hal_ver.c
  group src/hal/adc
    $TVII_SDL_710$/tviibe1m_backup/src/hal/adc/: hal_adc.c hal_adc.h hal_adc_calibration.c hal_adc_def.h
  group src/hal/clock
    $TVII_SDL_710$/tviibe1m_backup/src/hal/clock/: hal_clock.c hal_clock.h hal_clock_def.h
  group src/hal/crypto
    $TVII_SDL_710$/tviibe1m_backup/src/hal/crypto/: hal_crc.h hal_crc_def.h hal_crypto.c hal_crypto.h hal_hw_crc.c hal_sw_crc.c
  group src/hal/cy_hdr
    $TVII_SDL_710$/tviibe1m_backup/src/hal/cy_hdr/: cyhal_cyt2b75.h cyhal_hwmgr.c cyhal_hwmgr.h cyhal_pin_package.h
  group src/hal/fmc
    $TVII_SDL_710$/tviibe1m_backup/src/hal/fmc/: hal_fmc.c hal_fmc.h hal_fmc_def.h
  group src/hal/gpio
    $TVII_SDL_710$/tviibe1m_backup/src/hal/gpio/: hal_gpio.c hal_gpio.h hal_gpio_def.h
  group src/hal/hal_config
    $TVII_SDL_710$/tviibe1m_backup/src/hal/hal_config/: hal_adc_config.c hal_clock_config.c hal_crypto_config.c hal_fmc_config.c hal_gpio_config.c hal_i2c_config.c hal_pm_config.c hal_pwm_config.c hal_sp_config.c hal_spi_config.c hal_systick_config.c hal_timer_config.c hal_uart_config.c hal_wdt_config.c
  group src/hal/i2c
    $TVII_SDL_710$/tviibe1m_backup/src/hal/i2c/: hal_i2c.c hal_i2c.h hal_i2c_def.h
  group src/hal/jump
    $TVII_SDL_710$/tviibe1m_backup/src/hal/jump/: hal_jump.c hal_jump.h
  group src/hal/pm
    $TVII_SDL_710$/tviibe1m_backup/src/hal/pm/: hal_pm.c hal_pm.h hal_pm_def.h
  group src/hal/pwm
    $TVII_SDL_710$/tviibe1m_backup/src/hal/pwm/: hal_pwm.c hal_pwm.h hal_pwm_def.h
  group src/hal/sp
    $TVII_SDL_710$/tviibe1m_backup/src/hal/sp/: hal_sp.c hal_sp.h hal_sp_def.h
  group src/hal/spi
    $TVII_SDL_710$/tviibe1m_backup/src/hal/spi/: hal_spi.c hal_spi.h hal_spi_def.h
  group src/hal/srom
    $TVII_SDL_710$/tviibe1m_backup/src/hal/srom/: hal_silicon_info.c hal_silicon_info.h
  group src/hal/sysreset
    $TVII_SDL_710$/tviibe1m_backup/src/hal/sysreset/: hal_sysreset.c hal_sysreset.h hal_sysreset_def.h
  group src/hal/systick
    $TVII_SDL_710$/tviibe1m_backup/src/hal/systick/: hal_systick.c hal_systick.h hal_systick_def.h
  group src/hal/timer
    $TVII_SDL_710$/tviibe1m_backup/src/hal/timer/: hal_timer.c hal_timer.h hal_timer_def.h
  group src/hal/uart
    $TVII_SDL_710$/tviibe1m_backup/src/hal/uart/: hal_uart.c hal_uart.h hal_uart_def.h
  group src/hal/wdt
    $TVII_SDL_710$/tviibe1m_backup/src/hal/wdt/: hal_wdt.c hal_wdt.h hal_wdt_def.h
  group src/interrupts/rev_b
    $TVII_SDL_710$/tviibe1m_backup/src/interrupts/rev_b/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
  group src/interrupts/rev_c
    $TVII_SDL_710$/tviibe1m_backup/src/interrupts/rev_c/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
  group src/interrupts/rev_d
    $TVII_SDL_710$/tviibe1m_backup/src/interrupts/rev_d/: cy_interrupt_map.c cy_interrupt_map_cm0plus.h
  group src/mw/button
    $TVII_SDL_710$/common/src/mw/button/: cy_button.c cy_button.h
  group src/mw/flash
    $TVII_SDL_710$/common/src/mw/flash/: cy_mw_flash.c cy_mw_flash.h
  group src/mw/semihosting
    $TVII_SDL_710$/common/src/mw/semihosting/: cy_semihosting.c cy_semihosting.h
  group src/mw/sw_timer
    $TVII_SDL_710$/common/src/mw/sw_timer/: cy_sw_tmr.c cy_sw_tmr.h
  group src/startup
    $TVII_SDL_710$/common/src/startup/: startup.c startup_customize.h
    $TVII_SDL_710$/common/src/startup/iar/: startup_cm0plus.s
  group src/system/rev_b
    $TVII_SDL_710$/tviibe1m_backup/src/system/rev_b/: system_cyt2b7.h system_tviibe1m_cm0plus.c
  group src/system/rev_c
    $TVII_SDL_710$/tviibe1m_backup/src/system/rev_c/: system_cyt2b7.h system_tviibe1m_cm0plus.c
  group src/system/rev_d
    $TVII_SDL_710$/tviibe1m_backup/src/system/rev_d/: system_cyt2b7.h system_tviibe1m_cm0plus.c
  group testbed
    $TVII_SDL_710$/tviibe1m_backup/src/testbed/: CYTVII_B_E_1M_KIT_PIN.h main_cm0_testbed.c testbed_adc_die_temp.c testbed_adc_interrupt.c testbed_adc_normal_read.c testbed_adc_range_detect.c testbed_clock.c testbed_crypto_crc.c testbed_fmc.c testbed_gpio.c testbed_gpio_intr.c testbed_i2c_led_slave.c testbed_i2c_master.c testbed_i2c_mem_master.c testbed_i2c_slave.c testbed_power_mode.c testbed_pwm.c testbed_pwm_duty.c testbed_pwm_duty_interrupt.c testbed_pwm_period.c testbed_silicon_id.c testbed_simple_bootloader.c testbed_sp.c testbed_spi_master.c testbed_sysreset_cause.c testbed_systick.c testbed_timer.c testbed_timer_count_second.c testbed_uart_interrupt.c testbed_uart_polling.c testbed_wdt.c testbed_wdt_interrupt.c
